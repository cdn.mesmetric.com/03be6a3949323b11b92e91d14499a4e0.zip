Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: 36393F-Star 1-lågig med platta.IFC
Time: 2025-04-22T13:03:01
Written by: SwIFC
Made in: SolidWorks 2023

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: 10475 Kaschering Star light ø38 L=75 C-hål ø10
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 14953-69 Kopparbricka D=102x1,5 hålad Star
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 50336 LED-ljus MR11 mini 3,5W 230V GU10
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Del till 40358 Led 295
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Del2 till 40370 Led 295
In: Default Storey
PredefinedType: ELEMENT; Material: 0
